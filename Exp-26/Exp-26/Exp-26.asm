/*
 * Exp_26.asm
 *
 *  Created: 05-04-2022 10:53:42
 *   Author: SSM POLY
 */ 

 .include "M32DEF.inc"
 .macro initstack
	ldi r20,high(RAMEND)
	OUT SPH,R20
	LDI R20,LOW(RAMEND)
	OUT SPL,R20
.endmacro
	initstack
	LDI R16,1<<5
	SBI DDRB,5
	LDI R17,0
	OUT PORTB,R17
BEGIN:
	RCALL DELAY
	EOR R17,R16
	OUT PORTB,R17
	RJMP BEGIN


DELAY:
	LDI R20,0XF2
	OUT TCNT0,R20
	LDI R20,0X01
	OUT TCCR0,R20

AGAIN:
	IN R20,TIFR
	SBRS R20,TOV0
	RJMP AGAIN
	LDI R20,0X0
	OUT TCCR0,R20
	LDI R20,(1<<TOV0)
	OUT TIFR,R20
	RET
