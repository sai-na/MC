/*
 * EXP28.asm
 *
 *  Created: 05/04/2022 06:18:35
 *   Author: SSM
 */ 


.include "M32DEF.INC"
	
	LDI R16,0X08
	SBI DDRB,3
	LDI R17,0
BEGIN:
	OUT PORTB,R17
	RCALL DELAY
	EOR R17,R16
	RJMP BEGIN
DELAY:
	LDI R20,0
	OUT TCNT0,R20
	LDI R20,9
	OUT OCR0,R20
	LDI R20,0X09
	OUT TCCR0,R20
AGAIN:
	IN R20,TIFR
	SBRS R20,OCF0
	RJMP AGAIN
	LDI R20,0X0
	OUT TCCR0,R20
	LDI R20,1<<OCF0
	OUT TIFR,R20
	RET